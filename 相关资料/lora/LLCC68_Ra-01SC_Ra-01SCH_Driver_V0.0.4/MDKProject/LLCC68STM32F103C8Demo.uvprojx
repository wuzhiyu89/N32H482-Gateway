# Keil uVision project LLCC68STM32F103C8Demo.uvprojx, settings and files
target LLCC68STM32F103C8Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LLCC68STM32F103C8Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HAL\delay;..\HAL;..\peripherals\radio;..\peripherals\radio\llcc68;..\peripherals\radio\llcc68_example\llcc68_recive;..\peripherals\radio\llcc68_example\llcc68_send
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_tim.c
  group HAL
    ../HAL/delay/: delay.c
    ../HAL/: HAL_uart.c HAL_SPI.c LLCC68STM32F103-board.c
  group LLCC68Radio
    ../peripherals/radio/llcc68/: llcc68.c radio.c
  group LLCC68Example
    ../peripherals/radio/llcc68_example/llcc68_recive/: llcc68_example_recive.c
    ../peripherals/radio/llcc68_example/llcc68_send/: llcc68_example_send.c
